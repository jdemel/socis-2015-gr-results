<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>POLAR_encoder</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>framebits</key><value>2048</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>fec_generic_encoder</key>
<param><key>id</key><value>fec_encoder_block</value></param>
<param><key>encoder</key><value>POLAR_encoder</value></param>
<param><key>itype</key><value>byte</value></param>
<param><key>otype</key><value>byte</value></param>
</block>
<block>
<key>BSC</key>
<param><key>id</key><value>BSC_0</value></param>
</block>
<block>
<key>fec_generic_decoder</key>
<param><key>id</key><value>fec_decoder_block</value></param>
<param><key>decoder</key><value>POLAR_decoder</value></param>
<param><key>itype</key><value>byte</value></param>
<param><key>otype</key><value>byte</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>POLAR_decoder</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>framebits</key><value>2048</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>fec_encoder_block</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_decoder_block</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_encoder_block</source_block_id><sink_block_id>BSC_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>BSC_0</source_block_id><sink_block_id>fec_decoder_block</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
